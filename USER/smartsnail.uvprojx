# Keil uVision project smartsnail.uvprojx, settings and files
target smartsnail (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: smartsnail +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\CORE;..\STM32F0_FWLib\inc;..\USER;..\driver;..\Gizwits
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ./: main.c stm32f0xx_it.c system_stm32f0xx.c
  group CORE
    ../CORE/: startup_stm32f0xx.s
  group FWLIB
    ../STM32F0_FWLib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_pwr.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group driver
    ../driver/: gpio_driver.c delay.c time.c bsp_usart.c hal_key.c hal_motor.c bsp_dht11.c Hal_led.c hal_rgb_led.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
